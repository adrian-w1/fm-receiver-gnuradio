options:
  parameters:
    generate_options: qt_gui
    id: fm_sim
    output_language: python
    title: FM Simulation
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: '440000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14159*deviation/rf_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\user\Music\cooking\apache ahh.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """FM-Demodulator: m[n] = gain * arg(x[n] * conj(x[n-1]))"""

          def __init__(self, gain=1.0):
              gr.sync_block.__init__(
                  self,
                  name='My FM Demod',
                  in_sig=[np.complex64],
                  out_sig=[np.float32],
              )
              self.gain = gain
              self.last = np.complex64(1.0)  

          def work(self, input_items, output_items):
              x = input_items[0]
              prev = np.concatenate(([self.last], x[:-1]))
              output_items[0][:] = self.gain * np.angle(x * np.conj(prev))
              self.last = x[-1]
              return len(x)
    gain: rf_rate/(2*3.14159*deviation)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from scipy.signal import lfilter
      from gnuradio import gr


      class blk(gr.sync_block):
          """Pre-Emphasis: exakte Inverse des De-Emphasis-Filters"""

          def __init__(self, fs=48000.0, tau=50e-6):
              gr.sync_block.__init__(self, name='My Preemphasis',
                                     in_sig=[np.float32], out_sig=[np.float32])
              alpha = 1.0 - np.exp(-1.0 / (fs * tau))
              self.b = [1.0 / alpha, -(1.0 - alpha) / alpha]
              self.a = [1.0]
              self.zi = np.zeros(1) 

          def work(self, input_items, output_items):
              y, self.zi = lfilter(self.b, self.a, input_items[0], zi=self.zi)
              output_items[0][:] = y
              return len(y)
    fs: samp_rate
    tau: '50e-6'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from scipy.signal import lfilter
      from gnuradio import gr


      class blk(gr.sync_block):
          """De-Emphasis: y[n] = alpha*x[n] + (1-alpha)*y[n-1]"""

          def __init__(self, fs=48000.0, tau=50e-6):
              gr.sync_block.__init__(self, name='My Deemphasis',
                                     in_sig=[np.float32], out_sig=[np.float32])
              alpha = 1.0 - np.exp(-1.0 / (fs * tau))
              self.b = [alpha]
              self.a = [1.0, -(1.0 - alpha)]
              self.zi = np.zeros(1)

          def work(self, input_items, output_items):
              y, self.zi = lfilter(self.b, self.a, input_items[0], zi=self.zi)
              output_items[0][:] = y
              return len(y)
    fs: samp_rate
    tau: '50e-6'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '10'
    gain: '1'
    samp_rate: rf_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rf_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '480'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [epy_block_1, '0', rational_resampler_xxx_0, '0']
- [epy_block_2, '0', audio_sink_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', epy_block_2, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
